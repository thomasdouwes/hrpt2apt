options:
  parameters:
    author: Thomas Douwes
    generate_options: qt_gui
    id: apt_wav
    output_language: python
    title: APT dat to WAV
  states: {}

blocks:
- name: if_rate_1
  id: variable
  parameters:
    value: lines_per_second*samples_per_line
  states: {}
- name: if_rate_2
  id: variable
  parameters:
    value: if_rate_1*4
  states: {}
- name: if_rate_3
  id: variable
  parameters:
    value: if_rate_2*8
  states: {}
- name: if_rate_3_0
  id: variable
  parameters:
    value: if_rate_2*8
  states: {}
- name: lines_per_second
  id: variable
  parameters:
    value: '2'
  states: {}
- name: max_deviation
  id: variable
  parameters:
    value: 34000/2
  states: {}
- name: samples_per_line
  id: variable
  parameters:
    value: '2080'
  states: {}
- name: subcarrier_frequency
  id: variable
  parameters:
    value: '2400'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '255'
    type: float
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: (2*math.pi * max_deviation) / if_rate_3
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.87'
    freq: subcarrier_frequency
    offset: '0'
    phase: '0'
    samp_rate: if_rate_2
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: apt.dat
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_wavfile_sink_0_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: baseband.wav
    format: FORMAT_WAV
    nchan: '2'
    samp_rate: if_rate_3
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '4'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '8'
    type: fff
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_divide_xx_0, '1']
- [analog_frequency_modulator_fc_0, '0', blocks_multiply_const_vxx_1, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_complex_to_float_0, '0', blocks_wavfile_sink_0_0, '0']
- [blocks_complex_to_float_0, '1', blocks_wavfile_sink_0_0, '1']
- [blocks_divide_xx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_file_source_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_complex_to_float_0, '0']
- [blocks_multiply_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_divide_xx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_xx_0, '0']
- [rational_resampler_xxx_0_0, '0', analog_frequency_modulator_fc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
